options:
  parameters:
    generate_options: qt_gui
    id: file_testing
    output_language: python
  states: {}

blocks:
- name: Mod
  id: variable_constellation
  parameters:
    precision: '8'
    type: 16qam
  states: {}
- name: bits_mod
  id: variable
  parameters:
    value: '4'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '500000'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: rx.txt
    type: byte
  states: {}
- name: blocks_file_sink_1
  id: blocks_file_sink
  parameters:
    type: byte
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: File.txt
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_file_source_1
  id: blocks_file_source
  parameters:
    repeat: 'True'
    type: byte
  states: {state: disabled}
- name: blocks_repack_bits_bb_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: bits_mod
    l: '8'
  states: {state: disabled}
- name: blocks_repack_bits_bb_0_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '4'
    l: '8'
  states: {}
- name: blocks_repack_bits_bb_0_0_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '8'
    l: bits_mod
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {state: bypassed}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: Mod
  states: {}
- name: digital_constellation_encoder_bc_0
  id: digital_constellation_encoder_bc
  parameters:
    constellation: Mod
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: "#!/usr/bin/env python\n# -*- coding: utf-8 -*-\n#\n# Copyright 2022 dmitr.\n#\n# SPDX-License-Identifier: GPL-3.0-or-later\n#\n\n\nimport numpy as np\nfrom gnuradio import gr\n\nclass blk(gr.sync_block):\n    \"\"\"\n    docstring for block add_barking_code\n    \"\"\"\n    def __init__(self):\n        gr.sync_block.__init__(self,name=\"add_barking_code\",in_sig=[np.uint8], out_sig=[np.uint8])\n\n        self.barkersequence = [0, 0, 0, 0, 0, 1, 1, 0, 0, 1, 0, 1, 0, 0, 0, 0]*2\n        self.syncLength = len(self.barkersequence)\n        self.PACKET_SIZE = 1024\n\n    def work(self, input_items, output_items):\n\t#ПРИНИМАЕТ распакованные байты и добавляет коды баркера\n        if len(input_items[0]) > self.PACKET_SIZE and len(output_items[0]) > self.PACKET_SIZE + self.syncLength:\n            for i in range(len(self.barkersequence)):\n                output_items[0][i] = self.barkersequence[i]\n            for i in range(self.PACKET_SIZE):\n                output_items[0][self.syncLength+i] = input_items[0][i]\n            self.consume_each(self.PACKET_SIZE);\n            return self.PACKET_SIZE + self.syncLength\n        return 0\n\n"
  states: {state: disabled}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {state: disabled}
- name: network_tcp_sink_0
  id: network_tcp_sink
  parameters:
    mode: '2'
    port: '2000'
    type: byte
  states: {state: disabled}
- name: network_tcp_source_0
  id: network_tcp_source
  parameters:
    addr: 127.0.0.1
    port: '2000'
    server: 'False'
    type: byte
  states: {state: disabled}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    size: '1024'
    type: complex
  states: {}
- name: soapy_limesdr_source_0
  id: soapy_limesdr_source
  parameters:
    center_freq: 434e6
    samp_rate: samp_rate
    type: fc32
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: 434e6
    gain0: '40'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_throttle_0, '0']
- [blocks_repack_bits_bb_0_0, '0', blocks_file_sink_0, '0']
- [blocks_repack_bits_bb_0_0_0, '0', digital_constellation_encoder_bc_0, '0']
- [blocks_throttle_0, '0', blocks_repack_bits_bb_0_0_0, '0']
- [digital_constellation_decoder_cb_0, '0', blocks_repack_bits_bb_0_0, '0']
- [digital_constellation_encoder_bc_0, '0', uhd_usrp_sink_0, '0']
- [network_tcp_source_0, '0', blocks_repack_bits_bb_0, '0']
- [soapy_limesdr_source_0, '0', digital_constellation_decoder_cb_0, '0']
- [soapy_limesdr_source_0, '0', qtgui_const_sink_x_0, '0']

metadata:
  file_format: 1
