options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: rds_rx
    output_language: python
    title: Stereo FM receiver and RDS Decoder
  states: {}

blocks:
- name: decimation
  id: variable
  parameters:
    value: '8'
  states: {}
- name: freq
  id: variable_qtgui_range
  parameters:
    gui_hint: 0, 0,1, 1
    label: Frequency
    start: '77'
    step: '0.1'
    stop: '108'
    value: '100.5'
  states: {}
- name: freq_offset
  id: variable
  parameters:
    value: '250000'
  states: {}
- name: freq_tune
  id: variable
  parameters:
    value: freq*1e6 - freq_offset
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 2, 0,1, 1
    label: RF Gain
    start: '0'
    step: '1'
    stop: '49.6'
    value: '25'
  states: {}
- name: pilot_taps
  id: variable_band_pass_filter_taps
  parameters:
    gain: '1.0'
    high_cutoff_freq: '19020'
    low_cutoff_freq: '18980'
    samp_rate: '240000'
    type: complex_band_pass
    width: '1000'
    win: window.WIN_HAMMING
  states: {}
- name: rrc_taps
  id: variable_rrc_filter_taps
  parameters:
    alpha: '1.0'
    gain: '1.0'
    ntaps: '151'
    samp_rate: '19000'
    sym_rate: 19000/8
  states: {}
- name: rrc_taps_manchester
  id: variable
  parameters:
    value: '[rrc_taps[n] - rrc_taps[n+8] for n in range(len(rrc_taps)-8)]'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 19e3*20
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    gui_hint: 1, 0,1, 1
    label: Volume
    start: '-20'
    step: '1'
    stop: '10'
    value: '-6'
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '53'
    max_gain: '1000'
    rate: '2e-3'
    reference: '0.585'
    type: complex
  states: {state: disabled}
- name: analog_fm_deemph_0_0
  id: analog_fm_deemph
  parameters:
    samp_rate: '48000'
    tau: '75e-6'
  states: {state: disabled}
- name: analog_fm_deemph_0_0_0
  id: analog_fm_deemph
  parameters:
    samp_rate: '48000'
    tau: '75e-6'
  states: {state: disabled}
- name: analog_pll_refout_cc_0
  id: analog_pll_refout_cc
  parameters:
    max_freq: 2 * math.pi * 19020 / 240000
    min_freq: 2 * math.pi * 18980 / 240000
    w: '0.001'
  states: {state: disabled}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: (samp_rate / decimation) / (2*math.pi*75000)
  states: {state: disabled}
- name: audio_sink_0
  id: audio_sink
  parameters:
    num_inputs: '2'
    samp_rate: '48000'
  states: {state: disabled}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_complex_to_imag_0
  id: blocks_complex_to_imag
  parameters: {}
  states: {state: disabled}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: (len(pilot_taps) - 1) // 2
    type: float
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 10**(1.*(volume)/10)
    type: float
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 10**(1.*(volume)/10)
    type: float
  states: {state: disabled}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_multiply_xx_1
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: digital_constellation_receiver_cb_0
  id: digital_constellation_receiver_cb
  parameters:
    constellation: digital.constellation_bpsk().base()
    fmax: '0.002'
    fmin: '-0.002'
    loop_bw: 2*math.pi / 100
  states: {state: disabled}
- name: digital_diff_decoder_bb_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '2'
  states: {state: disabled}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: '0.01'
    max_dev: '0.1'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: '16'
    ted_gain: '1.0'
    ted_type: digital.TED_ZERO_CROSSING
    type: cc
  states: {state: disabled}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: pilot_taps
    type: fcc
  states: {state: disabled}
- name: fir_filter_xxx_1
  id: fir_filter_xxx
  parameters:
    decim: '5'
    taps: firdes.low_pass(1.0,240000,15e3,2e3)
    type: fff
  states: {state: disabled}
- name: fir_filter_xxx_1_0
  id: fir_filter_xxx
  parameters:
    decim: '5'
    taps: firdes.low_pass(-2.1,240000,15e3,2e3)
    type: fff
  states: {state: disabled}
- name: fir_filter_xxx_2
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: rrc_taps_manchester
    type: ccc
  states: {state: disabled}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: freq_offset
    decim: decimation
    samp_rate: samp_rate
    taps: firdes.low_pass(1, samp_rate, 100000, 20000)
    type: ccc
  states: {state: disabled}
- name: freq_xlating_fir_filter_xxx_1_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: 57e3
    decim: '10'
    samp_rate: samp_rate / decimation
    taps: firdes.low_pass(1.0, samp_rate / decimation, 7.5e3, 5e3)
    type: fcc
  states: {state: disabled}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: network_tcp_source_2
  id: network_tcp_source
  parameters:
    addr: 127.0.0.1
    port: '2000'
    server: 'False'
    type: complex
  states: {state: disabled}
- name: note_0
  id: note
  parameters:
    note: L+R
  states: {state: disabled}
- name: note_0_1
  id: note
  parameters:
    note: L-R
  states: {state: disabled}
- name: note_0_2
  id: note
  parameters:
    note: RDS
  states: {state: disabled}
- name: note_1
  id: note
  parameters:
    note: Pilot
  states: {state: disabled}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate / decimation
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate / decimation
    fc: '0'
    fftsize: '1024'
    freqhalf: 'False'
    int_max: '0'
    int_min: '-80'
    type: float
  states: {state: disabled}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: samp_rate // decimation
    interp: '240000'
    type: fff
  states: {state: disabled}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: int(samp_rate // decimation // 10)
    interp: '19000'
    type: ccc
  states: {state: disabled}
- name: rds_decoder_0
  id: rds_decoder
  parameters: {}
  states: {}
- name: rds_encoder_0
  id: rds_encoder
  parameters:
    af1: 100.5e6
    ms: 'True'
    pi_country_code: '13'
    pi_coverage_area: '3'
    pi_reference_number: '147'
    ps: WDR 3
    pty: '14'
    pty_locale: '0'
    radiotext: Reklama +7(812)5553535
    ta: 'False'
    tp: 'True'
  states: {}
- name: rds_panel_0
  id: rds_panel
  parameters:
    freq: freq
  states: {}
- name: rds_parser_0
  id: rds_parser
  parameters:
    pty_locale: '0'
  states: {}
- name: soapy_limesdr_source_0
  id: soapy_limesdr_source
  parameters:
    center_freq: freq
    samp_rate: samp_rate
    type: fc32
  states: {state: disabled}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: TX/RX
    center_freq0: freq_tune
    clock_rate: '0.0'
    dev_addr: ''
    dev_args: '""'
    gain0: gain
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {state: disabled}

connections:
- [analog_agc_xx_0, '0', digital_symbol_sync_xx_0, '0']
- [analog_fm_deemph_0_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [analog_fm_deemph_0_0_0, '0', blocks_multiply_const_vxx_0, '0']
- [analog_pll_refout_cc_0, '0', blocks_multiply_xx_0, '0']
- [analog_pll_refout_cc_0, '0', blocks_multiply_xx_0, '1']
- [analog_quadrature_demod_cf_0, '0', freq_xlating_fir_filter_xxx_1_0, '0']
- [analog_quadrature_demod_cf_0, '0', qtgui_waterfall_sink_x_0, '0']
- [analog_quadrature_demod_cf_0, '0', rational_resampler_xxx_0, '0']
- [blocks_add_xx_0, '0', analog_fm_deemph_0_0_0, '0']
- [blocks_complex_to_imag_0, '0', blocks_multiply_xx_1, '1']
- [blocks_delay_0, '0', blocks_multiply_xx_1, '0']
- [blocks_delay_0, '0', fir_filter_xxx_1, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', audio_sink_0, '1']
- [blocks_multiply_xx_0, '0', blocks_complex_to_imag_0, '0']
- [blocks_multiply_xx_1, '0', fir_filter_xxx_1_0, '0']
- [blocks_sub_xx_0, '0', analog_fm_deemph_0_0, '0']
- [blocks_throttle_0, '0', rds_decoder_0, '0']
- [digital_constellation_receiver_cb_0, '0', digital_diff_decoder_bb_0, '0']
- [digital_diff_decoder_bb_0, '0', rds_decoder_0, '0']
- [digital_symbol_sync_xx_0, '0', digital_constellation_receiver_cb_0, '0']
- [fir_filter_xxx_0, '0', analog_pll_refout_cc_0, '0']
- [fir_filter_xxx_1, '0', blocks_add_xx_0, '0']
- [fir_filter_xxx_1, '0', blocks_sub_xx_0, '0']
- [fir_filter_xxx_1_0, '0', blocks_add_xx_0, '1']
- [fir_filter_xxx_1_0, '0', blocks_sub_xx_0, '1']
- [fir_filter_xxx_2, '0', analog_agc_xx_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', analog_quadrature_demod_cf_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', qtgui_freq_sink_x_0, '0']
- [freq_xlating_fir_filter_xxx_1_0, '0', rational_resampler_xxx_1, '0']
- [network_tcp_source_2, '0', freq_xlating_fir_filter_xxx_0, '0']
- [rational_resampler_xxx_0, '0', blocks_delay_0, '0']
- [rational_resampler_xxx_0, '0', fir_filter_xxx_0, '0']
- [rational_resampler_xxx_1, '0', fir_filter_xxx_2, '0']
- [rds_decoder_0, out, rds_parser_0, in]
- [rds_encoder_0, '0', blocks_throttle_0, '0']
- [rds_parser_0, out, rds_panel_0, in]
- [soapy_limesdr_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [soapy_limesdr_source_0, '0', qtgui_freq_sink_x_0, '0']
- [uhd_usrp_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']

metadata:
  file_format: 1
