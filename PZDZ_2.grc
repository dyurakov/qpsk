options:
  parameters:
    generate_options: qt_gui
    id: file_testing
    output_language: python
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '500000'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/dmitr/save_pi/Desktop/rx.txt
    type: byte
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/dmitr/save_pi/Desktop/OFDM/File.txt
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_repack_bits_bb_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: digital_psk_demod_0
  id: digital_psk_demod
  parameters:
    constellation_points: '4'
    differential: 'True'
    excess_bw: '0.35'
    freq_bw: 6.28/100.0
    mod_code: '"gray"'
    phase_bw: 6.28/100.0
    samples_per_symbol: '2'
    timing_bw: 6.28/100.0
  states: {}
- name: digital_psk_mod_0
  id: digital_psk_mod
  parameters:
    constellation_points: '4'
    differential: 'True'
    excess_bw: '0.35'
    mod_code: '"gray"'
    samples_per_symbol: '2'
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: "#!/usr/bin/env python\n# -*- coding: utf-8 -*-\n#\n# Copyright 2022 dmitr.\n#\n# SPDX-License-Identifier: GPL-3.0-or-later\n#\n\n\nimport numpy as np\nfrom gnuradio import gr\n\nclass blk(gr.sync_block):\n    \"\"\"\n    docstring for block add_barking_code\n    \"\"\"\n    def __init__(self):\n        gr.sync_block.__init__(self,name=\"add_barking_code\",in_sig=[np.uint8], out_sig=[np.uint8])\n\n        self.barkersequence = [0, 0, 0, 0, 0, 1, 1, 0, 0, 1, 0, 1, 0, 0, 0, 0]*2\n        self.syncLength = len(self.barkersequence)\n        self.PACKET_SIZE = 1024\n\n    def work(self, input_items, output_items):\n\t#ПРИНИМАЕТ распакованные байты и добавляет коды баркера\n        if len(input_items[0]) > self.PACKET_SIZE and len(output_items[0]) > self.PACKET_SIZE + self.syncLength:\n            for i in range(len(self.barkersequence)):\n                output_items[0][i] = self.barkersequence[i]\n            for i in range(self.PACKET_SIZE):\n                output_items[0][self.syncLength+i] = input_items[0][i]\n            self.consume_each(self.PACKET_SIZE);\n            return self.PACKET_SIZE + self.syncLength\n        return 0\n\n"
  states: {state: disabled}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Print',   # will show up in GRC
                  in_sig=[np.complex64],
                  out_sig=[]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).


          def work(self, input_items):
              """example: multiply with constant"""
              #output_items[0][:] = input_items[0] * self.example_param
              print(len(input_items[0]))
              return len(input_items[0])
  states: {state: disabled}
- name: mylib_wifi_pmt_add_barking_code_0
  id: mylib_wifi_pmt_add_barking_code
  parameters: {}
  states: {}
- name: mylib_wifi_pmt_del_barking_code_0
  id: mylib_wifi_pmt_del_barking_code
  parameters: {}
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_throttle_0, '0']
- [blocks_repack_bits_bb_0, '0', mylib_wifi_pmt_del_barking_code_0, '0']
- [blocks_throttle_0, '0', mylib_wifi_pmt_add_barking_code_0, '0']
- [digital_psk_demod_0, '0', blocks_repack_bits_bb_0, '0']
- [digital_psk_mod_0, '0', digital_psk_demod_0, '0']
- [mylib_wifi_pmt_add_barking_code_0, '0', digital_psk_mod_0, '0']
- [mylib_wifi_pmt_del_barking_code_0, '0', blocks_file_sink_0, '0']

metadata:
  file_format: 1
